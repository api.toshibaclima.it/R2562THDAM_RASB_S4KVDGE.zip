Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 765dcccd-3ce8-4615-a682-4cc61b217cd2, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates]
File name: Project Number
Time: 2025-05-08T10:35:32+07:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.4.427 (ENU) - IFC 24.0.4.427

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 401672; RefLongitude: -71, -3, -24, -345703; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding, Building Name
LongName: Building Name
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head (2)
In: Building Name
Pset_ProductRequirements - Category: Levels
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name | Elevation (mm)
L1 | L1 | 0
L2 | L2 | 3600

# IfcBuildingElementProxy: R2562-T-HDAM_RAS-B_S4KVDG-E:RAS-B10S4KVDG-E, R2562-T-HDAM_RAS-B_S4KVDG-E:RAS-B10S4KVDG-E:1596026
In: L1
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Carrier Air Conditioning (Thailand)
Type - Pset_ProductRequirements - Category: Electrical Equipment
Type - Pset_ProvisionForVoid - Width: 940 mm; Height: 293 mm; Depth: 257 mm
Pset_BuildingElementProxyCommon - Reference: RAS-B10S4KVDG-E; sets with these values: 2
